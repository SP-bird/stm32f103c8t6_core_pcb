# Keil uVision project core_pcb.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: core_pcb +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\INTERRUPT;..\APP\app_inc;..\HARDWARE\KEY;..\OPEN_SOURCE\OLED;..\HARDWARE\WIFI;..\BUS\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c config.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/WIFI/: wifi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_exti.c
  group DEBUG
    ./: debug.h
  group APP
    ../APP/app_src/APP_LED/: app_led.c
    ../APP/app_src/APP_SOFT_TIMER/: app_soft_timer.c
    ../APP/app_src/APP_OLED/: app_oled.c
    ../APP/app_src/APP_WIFI/: app_wifi.c
  group INTERRUPT
    ../INTERRUPT/: timer3.c timer4.c timer2.c
  group OPEN_SOURCE
    ../OPEN_SOURCE/OLED/: oled.c
  group BUS
    ../BUS/src/: usart2.c
  group doc
    ../: README.TXT
